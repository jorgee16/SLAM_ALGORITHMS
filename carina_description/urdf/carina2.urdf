Commit message: updates

File: carina_description/urdf/carina2.urdf (robot description, URDF)
Before this commit: robot carina2, 5 links, 4 joints
Links:
- link chassi_link: geometry visual mesh filename=package://carina_description/meshes/Ford_fusion.obj scale=0.02 0.02 0.02
